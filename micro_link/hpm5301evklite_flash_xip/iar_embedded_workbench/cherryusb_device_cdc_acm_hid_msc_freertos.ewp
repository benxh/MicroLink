# IAR project cherryusb_device_cdc_acm_hid_msc_freertos.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5301xEGx HPMicro HPM5301xEGx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_DISABLE_GLOBAL_IRQ_ON_STARTUP=1; portasmHAS_MTIME=1; __freertos_irq_stack_top=_stack; CONFIG_FREERTOS=1; USE_NONVECTOR_MODE=1; DISABLE_IRQ_PREEMPTIVE=1
  ICCRISCV.CCIncludePath2: ../../hpm_sdk_localized_for_hpm5301evklite/arch; ../../hpm_sdk_localized_for_hpm5301evklite/boards/hpm5301evklite; ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301; ../../hpm_sdk_localized_for_hpm5301evklite/soc/ip; ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/toolchains; ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/boot; ../../hpm_sdk_localized_for_hpm5301evklite/drivers/inc; ../../hpm_sdk_localized_for_hpm5301evklite/utils; ../../hpm_sdk_localized_for_hpm5301evklite/components/usb; ../../hpm_sdk_localized_for_hpm5301evklite/components/enet_phy; ../../hpm_sdk_localized_for_hpm5301evklite/components/debug_console; ../../hpm_sdk_localized_for_hpm5301evklite/components/usb/device; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/include; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/common; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/osal; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/core; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/cdc; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/hid; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/midi; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/msc; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/audio; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/video; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/hub; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/wireless; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/port/ehci; ../build_tmp/generated/include; ../../../../../config; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/portable/IAR/RISC-V; ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/portable/IAR/RISC-V/chip_specific_extensions/HPMicro
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M
  ILINK.IlinkIcfFile: ..\..\hpm_sdk_localized_for_hpm5301evklite\soc\HPM5301\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_DISABLE_GLOBAL_IRQ_ON_STARTUP=1; portasmHAS_MTIME=1; __freertos_irq_stack_top=_stack; CONFIG_FREERTOS=1; USE_NONVECTOR_MODE=1; DISABLE_IRQ_PREEMPTIVE=1; NDEBUG
  group application/src
    E:/software/HPM5300/sdk_env/hpm_sdk/samples/cherryusb/device/composite/cdc_acm_hid_msc_freertos/src/: main.c cdc_acm_hid_msc.c
  group soc/HPM5301
    ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/: system.c hpm_sysctl_drv.c hpm_l1c_drv.c hpm_clock_drv.c hpm_otp_drv.c
  group soc/HPM5301/toolchains
    ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/toolchains/: reset.c trap.c
  group soc/HPM5301/toolchains/iar
    ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/toolchains/iar/: startup.s
  group soc/HPM5301/boot
    ../../hpm_sdk_localized_for_hpm5301evklite/soc/HPM5301/boot/: hpm_bootheader.c
  group middleware/FreeRTOS/Source
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/: croutine.c list.c queue.c stream_buffer.c tasks.c timers.c event_groups.c
  group middleware/FreeRTOS/Source/portable/IAR/RISC-V
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/portable/IAR/RISC-V/: port.c portASM.S
  group middleware/FreeRTOS/Source/portable/IAR/RISC-V/chip_specific_extensions/HPMicro
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/portable/IAR/RISC-V/chip_specific_extensions/HPMicro/: hpm_port.c
  group middleware/FreeRTOS/Source/portable/MemMang
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middleware/cherryusb/core
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/core/: usbd_core.c
  group middleware/cherryusb/port/hpm
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/port/hpm/: usb_dc_hpm.c
  group middleware/cherryusb/class/cdc
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/cdc/: usbd_cdc.c
  group middleware/cherryusb/class/hid
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/hid/: usbd_hid.c
  group middleware/cherryusb/class/msc
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/class/msc/: usbd_msc.c
  group middleware/cherryusb/osal
    ../../hpm_sdk_localized_for_hpm5301evklite/middleware/cherryusb/osal/: usb_osal_freertos.c
  group boards/hpm5301evklite
    ../../hpm_sdk_localized_for_hpm5301evklite/boards/hpm5301evklite/: pinmux.c board.c
  group drivers/src
    ../../hpm_sdk_localized_for_hpm5301evklite/drivers/src/: hpm_uart_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_crc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c
  group utils
    ../../hpm_sdk_localized_for_hpm5301evklite/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../hpm_sdk_localized_for_hpm5301evklite/components/debug_console/: hpm_debug_console.c
  group components/usb/device
    ../../hpm_sdk_localized_for_hpm5301evklite/components/usb/device/: hpm_usb_device.c
