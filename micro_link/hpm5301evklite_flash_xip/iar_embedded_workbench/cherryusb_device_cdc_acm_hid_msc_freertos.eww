<?xml version="1.0" encoding="UTF-8"?>
<workspace>
<project>
<path>$WS_DIR$\cherryusb_device_cdc_acm_hid_msc_freertos.ewp</path>
</project>
<batchBuild />
</workspace>